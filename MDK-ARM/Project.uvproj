# Keil uVision project Project.uvproj, settings and files
target HeatMeterAutoRead (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --bin  -o  ./Obj/Project.bin  ./Obj/Project.axf
  c flags: Optim=1 OneElfS=1
  c define: UPDATE,DEBUG,DEBUG_SHELL
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\USER\uCos_App;..\USER\uCos_App\tasks\inc;..\USER\uCos_App\app_down\inc;..\USER\uCos_App\app_flashmem\inc;..\USER\uCos_App\app_up_protocol\inc;..\USER\uCos_App\Protocol_Base\inc;..\USER\uCos_App\Protocol-Zigbee\inc;..\USER\uCos_App\public\inc;..\USER\uCos_App\SysLog\inc;..\USER\uCos_App\app_lcm\inc;..\USER\uC-CPU;..\USER\uC-LIB;..\USER\uCOS-II;..\USER\uCOS-II\Source;..\USER\uCOS-II\Ports\ARM-Cortex-M3\RealView;..\USER\STM32_BSP\inc;..\USER\FATFS\inc;..\USER\uCos_App\Fat_SD\inc;..\USER\uCos_App\app_down\inc\valve;..\USER\uCos_App\app_down\src\valve
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x68000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Obj\Project.sct
  group uC-App
    ../USER/uCos_App/: main.cpp
  group uC-App/tasks/src
    ../USER/uCos_App/tasks/src/: tasks.cpp tasks1.cpp tasks2.cpp tasks4.cpp tasks3.cpp task_uart_shell.c
  group uC-App/app_down/src
    ../USER/uCos_App/app_down/src/: meter.c Meter_Table.c timingpro.c uart0pro.c heat_cost_meter.c ModBus.c Valve.c
  group uC-App/app_flashmem/src
    ../USER/uCos_App/app_flashmem/src/: StoreManage.c
  group uC-App/Protocol_Base/src
    ../USER/uCos_App/Protocol_Base/src/: BaseProtocol.cpp StructProtocol.c
  group uC-App/app_up_protocol/src
    ../USER/uCos_App/app_up_protocol/src/: tasks_up.cpp
  group uC-App/Protocol-Zigbee/src
    ../USER/uCos_App/Protocol-Zigbee/src/: ReadMeterData.cpp ZigbeeProtocol.cpp TermControl.cpp
  group uC-App/public/src
    ../USER/uCos_App/public/src/: DateTime.c publicfunc.c Ul_array.c
  group uC-App/SysLog/src
    ../USER/uCos_App/SysLog/src/: SysLog.c
  group uC-App/app_lcm/src
    ../USER/uCos_App/app_lcm/src/: InterfaceFuns.cpp Lcd_Menu.cpp
  group uC-App/Fat-SD/src
    ../USER/uCos_App/Fat_SD/src/: fat_sd.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c cortexm3_macro.s
    ../Libraries/CMSIS/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group uC-OS-II/Config
    ../USER/uCOS-II/: OS_AppHooks.c os_cfg.h
  group uC-OS-II/CPU
    ../USER/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm cpu.h
    ../USER/uC-CPU/: cpu_def.h
  group uC-OS-II/Source
    ../USER/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Port
    ../USER/uCOS-II/Ports/ARM-Cortex-M3/RealView/: os_dbg.c os_cpu_c.c os_cpu.h os_cpu_a.asm
  group STM32_BSP/src
    ../USER/STM32_BSP/src/: ASCIICode.c Bps_i2c.c commap.c gpioint.c HZTable.c lcmdrv.c PictureCode.c queue.c rx8025.c stm32f10x_it.c TaskDog.c Uart4.c Uart5.c Usart1.c Usart2.c bsp.c SPI_MSD_Driver.c gprs.c Usart3.c
  group FATFS/src
    ../USER/FATFS/src/: diskio.c ff.c syscall.c ccsbcs.c
  group uC_App/app_down/src/valve
    ../USER/uCos_App/app_down/src/valve/: valve_binihi.c valve_delu.c valve_elsonic.c valve_joyo.c valve_lcarbo.c valve_precise.c valve_ADE.c tempgather_guoneng.c panelwired_elsonic.c valve_guoneng.c
